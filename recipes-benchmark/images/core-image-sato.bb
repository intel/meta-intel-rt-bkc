require recipes-sato/images/core-image-sato.bb

DESCRIPTION = "glmark2 is 3D benchmark testing tool"

IMAGE_INSTALL += "glmark2"

LICENSE = "MIT"
