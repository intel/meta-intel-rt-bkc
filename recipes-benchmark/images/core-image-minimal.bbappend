# Adding stressful application test case
IMAGE_INSTALL += "stressapptest"
