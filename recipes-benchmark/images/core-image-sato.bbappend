# Adding glmark2 3D benchmark test case and stressful application test case
IMAGE_INSTALL += "glmark2 stressapptest"
