INSANE_SKIP_pn-kernel-devsrc = "debug-files rpaths"

RDEPENDS_${PN} += "python elfutils"

