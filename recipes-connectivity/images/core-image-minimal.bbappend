# Adding ssh service to minimal image
IMAGE_FEATURES += "ssh-server-openssh"
