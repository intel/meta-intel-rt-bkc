FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += " file://0001-adding-cpulist-option-support.patch"
